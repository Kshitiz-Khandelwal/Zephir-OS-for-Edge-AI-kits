## build-14/Kconfig/boards/Kconfig
```kconfig
# Load Zephyr board Kconfig descriptions.
osource "C:/zephyrproject/zephyr/boards/raspberrypi/rpi_pico2/Kconfig"
```
